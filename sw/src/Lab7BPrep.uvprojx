# Keil uVision project Lab7BPrep.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab7BPrep
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c misc: --std=c99 -Wno-c11-extensions
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Lab7Steering
    ./: main.c Timers.c Timers.h Paddles.c Paddles.h ADC.h ADC.c
    ../inc/: PLL.c Timer0A.c startup.s Timer1A.c ADCT0ATrigger.c UART.c UART2.c Timer2A.c
software components: CMSIS:CORE 6.1.0
